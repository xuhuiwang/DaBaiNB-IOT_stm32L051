# Keil uVision project Project.uvprojx, settings and files
target STM32L051C8 DaBai_IOT (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: STM32L051C8T6
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L051xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER
  c misc: --C99
  c include: .\Drivers\STM32L0xx_HAL_Driver\Inc;.\RTE\_STM32L051C8_DaBai_IOT;.\DaBai_Inc;.\Drivers\CMSIS\Device\ST\STM32L0xx\Include;.\Drivers\CMSIS\Include;.\Drivers\STM32L0xx_HAL_Driver\Inc\Legacy;.\DaBai_APP
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
  group DaBai_APP
    ./DaBai_APP/: DaBai_APP.c
  group DaBai_BSP
    ./DaBai_Src/: main.c stm32l0xx_hal_msp.c stm32l0xx_it.c DaBai_GPIO.c DaBai_i2c.c DaBai_usart.c DaBai_ADC.c DaBai_tim.c sht20_cfg.c
  group Doc
    ./: readMe.txt
  group Example/MDK-ARM
    ./: startup_stm32l051xx.s
  group Drivers/CMSIS
    ./DaBai_Src/: system_stm32l0xx.c
  group Drivers/STM32L0xx_HAL_Driver
    ./Drivers/STM32L0xx_HAL_Driver/Src/: stm32l0xx_hal_adc.c stm32l0xx_hal_adc_ex.c stm32l0xx_hal_gpio.c stm32l0xx_hal_cortex.c stm32l0xx_hal_rcc.c stm32l0xx_hal_dma.c stm32l0xx_hal.c stm32l0xx_hal_rcc_ex.c stm32l0xx_hal_i2c.c stm32l0xx_hal_i2c_ex.c stm32l0xx_hal_uart.c stm32l0xx_hal_uart_ex.c stm32l0xx_hal_usart.c stm32l0xx_hal_tim.c stm32l0xx_hal_tim_ex.c
target STM32L031K6_NUCLEO (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32L051C8Tx STMicroelectronics
  pack: Keil.STM32L0xx_DFP.2.0.0
  cpu: as above
  output: STM32L051C8T6
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32L051xx,USE_STM32L0XX_NUCLEO,USE_HAL_DRIVER
  c misc: --C99
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/ST/STM32L0xx/Include;../../../../../../Drivers/STM32L0xx_HAL_Driver/Inc;../../../../../../Drivers/BSP/STM32L0xx_Nucleo_32
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  link misc: --diag_suppress=L6329
software components: CMSIS:CORE 5.1.1
